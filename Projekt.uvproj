# Keil uVision project Projekt.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: Projekt
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ausgabea.a51 ausgabeb.a51 console.a51 main.a51 seriell.a51 scheduler.a51
